File: ergogen/pcbs/not_about_money.kicad_pcb (KiCad board)
At the start: 2 copper layers, 118 x 80 mm, 57 parts

Commit message: Update assets
Parts:
- moved RST1 4.00 mm to (132.5, 33.8)
